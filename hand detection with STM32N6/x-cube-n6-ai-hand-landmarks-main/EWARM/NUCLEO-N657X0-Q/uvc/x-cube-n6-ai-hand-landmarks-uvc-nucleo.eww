<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\x-cube-n6-ai-hand-landmarks-uvc-nucleo.ewp</path>
    </project>
    <batchBuild />
</workspace>